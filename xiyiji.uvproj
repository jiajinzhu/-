# Keil uVision project xiyiji.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: xiyiji +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: xiyiji.c Timer.C OLED_SSD1306.C Chinese_Font_Lib.C Serial_Port.c DS18B20.C AD_Covert.C KESHE.c baojing.c
